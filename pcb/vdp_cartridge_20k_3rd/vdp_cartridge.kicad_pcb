# Repository t-bucchi/V9968_Cartridge

## KiCad design pcb/vdp_cartridge_20k_3rd/vdp_cartridge.kicad_pcb

Parts:
C1: 100uF; C_1210_3225Metric; LCSC C49066
C2, C4, C5, C6, C8: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C1525
C3: 15pF; C_0805_2012Metric; LCSC C63339
J1: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
JP1, JP2: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Horizontal
Q1, Q2, Q3: BSS138; SOT-23; LCSC C2589
R2: 10kΩ; R_0805_2012Metric; LCSC C17414
R4, R5: 3.3kΩ; R_0805_2012Metric; LCSC C26010
U2: TangNano20K
U3: MSX Cartridge_1
U4: TSSOP-24_4.4x5mm_P0.4mm; LCSC C19197
U7, U8: 74LVC541; TSSOP-20_4.4x6.5mm_P0.65mm
X1: SG-8002DC; DIP-8_W7.62mm

Connections:
3V3: C2.1, C4.1, C6.1, C8.1, J1.1, JP1.1 (A), JP2.1 (A), R5.1, U2.19 (3V3), U4.1 (VCCA), U7.20 (VCC), U8.20 (VCC), X1.8 (Vdd)
5V: C1.1, C5.1, U2.40 (5V), U3.45 (+5V), U3.47 (+5V), U4.23 (VCCB), U4.24 (VCCB)
A0: U3.28 (A0), U7.9 (A7)
A1: U3.27 (A1), U7.8 (A6)
A2: U3.30 (A2), U7.7 (A5)
A3: U3.29 (A3), U7.6 (A4)
A4: U3.32 (A4), U7.5 (A3)
A5: U3.31 (A5), U7.4 (A2)
A6: U3.22 (A6), U7.3 (A1)
A7: U3.21 (A7), U7.2 (A0)
CLOCK: C3.1, U2.37 (IOT27A(80):SDIO_D2), X1.5 (OUT)
D0: U3.34 (D0), U4.21 (B1)
D1: U3.33 (D1), U4.20 (B2)
D2: U3.36 (D2), U4.19 (B3)
D3: U3.35 (D3), U4.18 (B4)
D4: U3.38 (D4), U4.17 (B5)
D5: U3.37 (D5), U4.16 (B6)
D6: U3.40 (D6), U4.15 (B7)
D7: U3.39 (D7), U4.14 (B8)
DIPSW0: JP1.2 (B), U2.22 (IOR38B(53))
DIPSW1: JP2.2 (B), U2.21 (IOR39A(52))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, J1.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), R2.2, R4.2, U2.20 (GND), U2.26 (GND), U2.39 (GND), U3.41 (GND), U3.43 (GND), U4.11 (GND), U4.12 (GND), U4.13 (GND), U7.10 (GND), U8.2 (A0), U8.4 (A2), U8.6 (A4), U8.8 (A6), U8.10 (GND), X1.4 (GND)
I2S_BCLK: J1.5, U2.34 (IOR36A(56))
I2S_DIN: J1.4, U2.33 (IOR38A(54))
I2S_EN: J1.6, U2.32 (IOR45A(51))
I2S_LRCLK: J1.3, U2.30 (IOR36B(55))
unnamed: U3.44 (SW1), U3.46 (SW2)
SLOT_A0: U2.13 (IOB14B(30)), U7.11 (Y7)
SLOT_A1: U2.14 (IOB29A(31)), U7.12 (Y6)
SLOT_A2: U2.38 (IOT30B(76)), U7.13 (Y5)
SLOT_A3: U2.36 (IOB42B(42)), U7.14 (Y4)
SLOT_A4: U2.35 (IOB43A(41)), U7.15 (Y3)
SLOT_A5: U2.31 (IOR49B(48)), U7.16 (Y2)
SLOT_A6: U2.29 (IOR49A(49)), U7.17 (Y1)
SLOT_A7: U2.15 (IOL49A(17)), U7.18 (Y0)
SLOT_D0: U2.12 (IOB14A(29)), U4.3 (A1)
SLOT_D1: U2.9 (IOB8B(28)), U4.4 (A2)
SLOT_D2: U2.8 (IOB8A(27)), U4.5 (A3)
SLOT_D3: U2.5 (IOT30A(77)), U4.6 (A4)
SLOT_D4: U2.4 (IOT4B(85):SDIO_D1), U4.7 (A5)
SLOT_D5: U2.3 (IOT34A(75)), U4.8 (A6)
SLOT_D6: U2.2 (IOT34B(74)), U4.9 (A7)
SLOT_D7: U2.1 (IOT40A(73)), U4.10 (A8)
SLOT_DATA_DIR: Q1.1 (G), R2.1, U2.17 (IOL51A(19)), U4.2 (DIR)
SLOT_INT: Q3.1 (G), R4.1, U2.23 (IOT44A(71))
SLOT_IORQ_N: U2.18 (IOL49B(18)), U8.11 (Y7)
SLOT_OE_N: U2.16 (IOL51B(20)), U4.22 (OEn), U7.1 (G1), U7.19 (G2), U8.1 (G1), U8.19 (G2)
SLOT_RD_N: U2.6 (IOL47A(15)), U8.15 (Y3)
SLOT_RESET_N: U2.28 (IOT4A(86)), U8.17 (Y1)
SLOT_WAIT: Q2.1 (G), R5.2, U2.24 (IOT40B(72))
SLOT_WR_N: U2.7 (IOT47B(16)), U8.13 (Y5)
/BUSDIR: Q1.3 (D), U3.10 (/BUSDIR)
/INT: Q3.3 (D), U3.8 (/INT)
/IORQ: U3.11 (/IORQ), U8.9 (A7)
/RD: U3.14 (/RD), U8.5 (A3)
/RESET: U3.15 (/RESET), U8.3 (A1)
/WAIT: Q2.3 (D), U3.7 (/WAIT)
/WR: U3.13 (/WR), U8.7 (A5)

Notes on the sheet:
I/O SELECT 0: 88h (OPEN) 1: 98h（SHORT）
SLOT_INT : 1 → /INT=0 0 or HiZ → /INT=HiZ
TO236AB Vgs(th) = 1.25V
OE は、OPEN か H で CLK を出力、L で CLK が HiZ になる。
TangNano20K
BUSDIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
14.318180MHz
※正論理
SLOT_DATA_DIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
SLOT_WAIT : 1 or HiZ → /WAIT=0 0 → /WAIT=HiZ
SN74LVC8T245DBR 24SSOP
FORCE HIGHSPEED 0: NORMAL（OPEN） 1: HIGHSPEED（SHORT）
/BUSDIR 1: CPU → Cartridge (WRITE) 0: CPU ← Cartridge (READ)

Board: 2 copper layers, 95.2 x 65.4 mm, 24 parts (0 on the bottom side), 58 nets.

Other parts of the board:
G1: LOGO; usa_10x7
G3: LOGO; msx_logo_15x5p8

Notices in the files:
pcb/vdp_cartridge_20k_3rd/vdp_cartridge.kicad_pcb:
Copyright 2026 HRA!
